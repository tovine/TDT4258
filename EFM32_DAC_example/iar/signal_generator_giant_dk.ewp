# IAR project signal_generator_giant_dk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32GG\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32GG_DK3750\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: signal_generator_giant_dk.bin
  ILINK.IlinkOutputFile: signal_generator_giant_dk.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../kits/common/bsp/: bsp_dk_3201.c
  group drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_system.c em_cmu.c em_emu.c em_dac.c em_prs.c em_ebi.c em_timer.c em_dma.c em_gpio.c em_usart.c
  group Source
    ../: main_dac_signal_generator_gg.c
