# IAR project dac_wav_player_gecko_dk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32G\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\reptile\fatfs\inc; ..\..\..\kits\common\drivers; ..\..\..\kits\EFM32_Gxxx_DK\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_wav_player_gecko_dk.bin
  ILINK.IlinkOutputFile: dac_wav_player_gecko_dk.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group DVK
    ../../../kits/common/bsp/: bsp_dk_3200.c
  group drivers
    ../../../kits/common/drivers/: dmactrl.c
  group FatFS
    ../../../kits/common/drivers/: microsd.c
    ../../../reptile/fatfs/src/: diskio.c ff.c
  group emlib
    ../../../emlib/src/: em_system.c em_cmu.c em_emu.c em_dac.c em_prs.c em_timer.c em_dma.c em_gpio.c em_usart.c
  group Source
    ../: main_dac_audio.c
