# Keil uVision project dac_wav_player_gecko_dk.uvproj, settings and files
target dac_wav_player_gecko_dk (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: dac_wav_player_gecko_dk
  AfterMake: fromelf.exe --bin --output obj\dac_wav_player_gecko_dk.bin obj\dac_wav_player_gecko_dk.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32G\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\reptile\fatfs\inc;..\..\..\kits\common\drivers;..\..\..\kits\EFM32_Gxxx_DK\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group DVK
    ../../../kits/common/bsp/: bsp_dk_3200.c
  group drivers
    ../../../kits/common/drivers/: dmactrl.c
  group FatFS
    ../../../kits/common/drivers/: microsd.c
    ../../../reptile/fatfs/src/: diskio.c ff.c
  group emlib
    ../../../emlib/src/: em_system.c em_cmu.c em_emu.c em_dac.c em_prs.c em_timer.c em_dma.c em_gpio.c em_usart.c
  group Source
    ../: main_dac_audio.c
