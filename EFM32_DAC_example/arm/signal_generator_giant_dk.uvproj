# Keil uVision project signal_generator_giant_dk.uvproj, settings and files
target signal_generator_giant_dk (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: signal_generator_giant_dk
  AfterMake: fromelf.exe --bin --output obj\signal_generator_giant_dk.bin obj\signal_generator_giant_dk.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32GG_DK3750\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../kits/common/bsp/: bsp_dk_3201.c
  group drivers
    ../../../kits/common/drivers/: dmactrl.c
  group emlib
    ../../../emlib/src/: em_system.c em_cmu.c em_emu.c em_dac.c em_prs.c em_ebi.c em_timer.c em_dma.c em_gpio.c em_usart.c
  group Source
    ../: main_dac_signal_generator_gg.c
